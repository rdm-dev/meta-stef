require xbmc.inc
SRCREV="a5a4495c8dd4030a0bc94b33caaebef74d0b2ef1"

PR = "${INC_PR}.2"
